# IAR project Backup (2) of CV060_Boot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3Sx8xx TexasInstruments LM3Sx8xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM3S8962; __HW060; __COMPILER2; __BOOT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: System; $PROJ_DIR$; Hardware_Stellaris; Hardware_Stellaris\boards; Hardware_Stellaris\boards\ek-lm3s8962; Hardware_Stellaris\third_party\lwip-1.3.2\apps; Hardware_Stellaris\third_party\lwip-1.3.2\ports\stellaris\include; Hardware_Stellaris\third_party\lwip-1.3.2\src\include; Hardware_Stellaris\third_party\lwip-1.3.2\src\include\ipv4; Hardware_Stellaris\third_party\lwip-1.3.2\src\ftp; Hardware_Stellaris\third_party; Hardware_Stellaris\third_party\fatfs; Hardware_Stellaris\third_party\fatfs\port; Hardware_Stellaris\third_party\fatfs\src
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .; ..; ..\..\..; ..\..\..\third_party\lwip-1.3.1\apps; ..\..\..\third_party\lwip-1.3.1\ports\stellaris\include; ..\..\..\third_party\lwip-1.3.1\src\include; ..\..\..\third_party\lwip-1.3.1\src\include\ipv4
  OBJCOPY.OOCOutputFile: CV060_Boot.bin
  ILINK.IlinkOutputFile: CV060.out
  ILINK.IlinkIcfFile: enet_io.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: enet_io.icf
    ../../System/: main.c
    System/: main_stellaris.c
  group FAT
    Hardware_Stellaris/third_party/fatfs/port/: AT45_fat.c
    Hardware_Stellaris/third_party/fatfs/src/: ff.c
  group FTP
    Hardware_Stellaris/third_party/lwip-1.3.2/src/ftp/: ftpd.c
  group Hardware
    Hardware_Stellaris/EL/: functions.c
    Hardware_Stellaris/I2C/: i2c.c
  group Stellaris
    ./: bl_flash.c cgifuncs.c enet_io.c io.c jump.asm lmi_fs.c lmi_fs_old.c startup_ewarm.c
    ../HW060_BootHardware_Stellaris/third_party/lwip-1.3.2/apps/custom_port/: cv_port.h modbus_port.c
    Hardware_Stellaris/third_party/lwip-1.3.2/apps/httpserver_raw/: httpd.c
    ../HW060_BootHardware_Stellaris/third_party/lwip-1.3.1/apps/httpserver_raw/: httpd_old.c
    Hardware_Stellaris/utils/: locator.c lwiplib.c ustdlib.c
  group Stellaris/Libraries
    Hardware_Stellaris/driverlib/ewarm/Exe/: driverlib.a
  group System
    System/IO/: adc.c
    System/Console/: console.c str.c
    System/Misc/: crc.c
    Custom/: custom.c
    System/Service/: plm.c
    System/Timer/: timer16_test.c
    System/Xmodem/: xmodem.c
  group System/Compiler2
    ../../System/Compiler2/: compiler2.c compiler2_goto.c compiler2_math.c
  group System/Memory
    System/AT45/: AT45_256.c
    System/Memory/: fram31xx.c
  group System/ModBus
    System/MODBus_Master/: modbus_functions.c modbus_protocol.c modbus_utils.c
  group System/RS485_Slave
    System/RS485_Slave/: RS485_S_functions.c RS485_S_protocol.c
    System/Socket_Slave/: socket_protocol.c
