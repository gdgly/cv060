<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\HW060_06\CV060_06.ewp</path>
    <scc>
      <provider>Subversion</provider>
      <projname>notused</projname>
      <auxprojpath>notused</auxprojpath>
    </scc>
  </project>
  <project>
    <path>$WS_DIR$\HW060_Boot\CV060_Boot.ewp</path>
    <scc>
      <provider>Subversion</provider>
      <projname>notused</projname>
      <auxprojpath>notused</auxprojpath>
    </scc>
  </project>
  <batchBuild/>
</workspace>


