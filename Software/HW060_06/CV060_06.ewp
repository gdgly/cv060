# IAR project CV060_06.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3Sx8xx TexasInstruments LM3Sx8xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM3S8962; __HW060; __COMPILER2; PRJ_NAME="$PROJ_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: System; $PROJ_DIR$; Hardware_Stellaris; Hardware_Stellaris\third_party\lwip-in-use\apps; Hardware_Stellaris\third_party\lwip-in-use\ports\stellaris\include; Hardware_Stellaris\third_party\lwip-in-use\src\include; Hardware_Stellaris\third_party\lwip-in-use\src\include\ipv4; Hardware_Stellaris\third_party\lwip-in-use\apps\ftp; Hardware_Stellaris\third_party; Hardware_Stellaris\third_party\fatfs; Hardware_Stellaris\third_party\fatfs\port; Hardware_Stellaris\third_party\fatfs\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .; ..; ..\..\..; ..\..\..\third_party\lwip-1.3.1\apps; ..\..\..\third_party\lwip-1.3.1\ports\stellaris\include; ..\..\..\third_party\lwip-1.3.1\src\include; ..\..\..\third_party\lwip-1.3.1\src\include\ipv4
  OBJCOPY.OOCOutputFile: CV060.bin
  ILINK.IlinkOutputFile: CV060.out
  ILINK.IlinkIcfFile: enet_io.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: enet_io.icf
    System/: main_stellaris.c
  group FAT
    Hardware_Stellaris/third_party/fatfs/port/: AT45_fat.c
    Hardware_Stellaris/third_party/fatfs/src/: ff.c
  group FTP
    Hardware_Stellaris/third_party/lwip-in-use/apps/ftp/: ftpd.c
  group Hardware
    System/: functions.c
    Hardware_Stellaris/I2C/: i2c.c
  group Stellaris
    ./: cgifuncs.c enet_io.c io.c lmi_fs.c nvic_init.asm startup_ewarm.c
    Hardware_Stellaris/third_party/lwip-in-use/apps/httpserver_raw/: httpd.c
    Hardware_Stellaris/utils/: locator.c lwiplib.c ustdlib.c
    Hardware_Stellaris/third_party/lwip-in-use/apps/custom_port/: modbus_port.c regs_server.c
  group Stellaris/Libraries
    Hardware_Stellaris/driverlib/ewarm/Exe/: driverlib.a
  group System
    System/IO/: adc.c
    System/Console/: console.c ip_console.c MenuItems_FILE.c MenuItems_SERVICE.c MenuItems_SET.c str.c
    System/Misc/: crc.c
    Custom/: custom.c fancoil.c
    System/Service/: errors.c plm.c
    System/Kotel/: kotel.c
    System/Named_Variables/: nvar.c
    System/Pid/: pid.c
    System/Season/: season.c
    System/Timer/: timer16_test.c
    System/Valve_3t/: valve_3t.c
    System/Xmodem/: xmodem.c
  group System/Compiler2
    System/Compiler2/: compiler2.c compiler2_goto.c compiler2_math.c
  group System/Indication
    System/Indication/: indication.c
  group System/INI_File
    System/Ini/: ini.c
  group System/IO_Expander
    System/MCP23016/: MCP23016.c
  group System/Memory
    System/AT45/: AT45_256.c
    System/Memory/: fram31xx.c
  group System/ModBus
    System/MODBus_Master/: modbus_functions.c modbus_protocol.c modbus_utils.c
  group System/RS485_Slave
    System/RS485_Slave/: RS485_S_functions.c RS485_S_protocol.c
    System/Socket_Slave/: socket_protocol.c
  group System/RTC
    System/DS1337/: DS1337.c
